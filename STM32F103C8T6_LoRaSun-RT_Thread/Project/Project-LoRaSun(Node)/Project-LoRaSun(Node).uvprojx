# Keil uVision project Project-LoRaSun(Node).uvprojx, settings and files
target Project-LoRaSun(Node) (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KKK
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Applications;.\Applications\sys;..\..\RT-Thread\include;..\..\RT-Thread\libcpu\arm\cortex-m3;..\..\RT-Thread\include\libc;..\..\RT-Thread\components\drivers;..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\StdPeriph_Driver\inc;.;..\..\Drivers;..\..\Drivers\MQTT;..\..\Drivers\sx1278;..\..\Drivers\encrypt;..\..\Drivers\LoRaSun;..\..\Drivers\sx1268
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph_Driver
    ../../Libraries/StdPeriph_Driver/: f103c8t6.lib
    ../../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ./Applications/sys/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group Applications
    ./Applications/: main.c user_opt.h user_app.c app_node.c app_oled96.c
    ./: rtconfig.h
  group Drivers
    ../../Drivers/: drv_common.c drv_uart.c board.c drv_iic.c drv_encrypt.c drv_oled96.c
  group RT-Thread
    ../../RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
    ../../RT-Thread/components/drivers/: ringbuffer.c
  group MQTT
    ../../Drivers/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Encrypt
    ../../Drivers/encrypt/mbedtls/: aes.c
  group LoRaSun
    ../../Drivers/LoRaSun/: nwk_node.c nwk_bsp.c nwk_aes.c
  group SX1278
    ../../Drivers/sx1278/: hal_sx1278.c drv_sx1278.c
  group SX1268
    ../../Drivers/sx1268/: drv_sx1268.c hal_sx1268.c
